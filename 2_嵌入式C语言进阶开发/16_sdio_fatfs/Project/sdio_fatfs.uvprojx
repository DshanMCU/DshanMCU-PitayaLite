# Keil uVision project sdio_fatfs.uvprojx, settings and files
target sdio_fatfs (6160000::V6.16::ARMCLANG)
  device: MM32F3273G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdio_fatfs +hex
  AfterMake: fromelf --bin -o "@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\1_Main;..\3_Drivers\Inc;..\4_MM32F327x;..\4_MM32F327x\CMSIS\Include;..\4_MM32F327x\drivers;..\2_Components\ff14b\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\4_MM32F327x\mdk\linker\mm32f3277g_flash.scf
  group App
    ../1_Main/: main.c
  group Drivers
    ../3_Drivers/Src/: drv_led.c drv_sdio.c drv_sysclk.c drv_systick.c drv_uart.c
  group MM32F327x_Core
    ../4_MM32F327x/: system_mm32f3277g.c
    ../4_MM32F327x/mdk/: startup_mm32f3277g.s
  group MM32F327x_HAL_Driver
    ../4_MM32F327x/drivers/: hal_adc.c hal_comp.c hal_dac.c hal_dma.c hal_exti.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_syscfg.c hal_tim_16b.c hal_tim_32b.c hal_tim_adv.c hal_tim_basic.c hal_uart.c hal_usb.c hal_wwdg.c hal_common.h
  group ff14b
    ../3_Drivers/Src/: diskio.c
    ../2_Components/ff14b/source/: ff.c ffsystem.c ffunicode.c
